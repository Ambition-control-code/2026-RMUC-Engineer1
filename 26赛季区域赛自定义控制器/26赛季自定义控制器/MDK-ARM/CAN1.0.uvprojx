# Keil uVision project CAN1.0.uvprojx, settings and files
target CAN1.0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CAN1.0 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./User;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;./BMI088;./DSP/include;./DSP;./filter;./DH_g;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;.\tools
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group User
    ./User/: can_bsp.c can_bsp.h can_driver.c can_driver.h Motor_contol.c Motor_control.h PID.c PID.h remote.c remote.h CRC.c CRC.h Send_MyData.c Send_MyData.h Switch_task.c Switch_task.h filter.c filter.h Freertos_task.c Freertos_task.h uart_bsp.c uart_bsp.h bits_change.c bits_change.h Get_Referee_Data.c Get_Referee_Data.h get_arm_data.c get_arm_data.h Key.c Key.h RGB_light.c RGB_light.h
  group Application/User/Core
    ./User/: ALL.c ALL.h
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group BMI088
    ./BMI088/: AHRS_middle.c AHRS_middle.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h struct_typedef.h BMI088driver.c BMI088driver.h IMU.c IMU.h flash.c flash.h MY_AHRS.c MY_AHRS.h
  group DH_g
    ./DH_g/: DH_g.c DH_g.h GC.c GC.h Gravity.c Gravity.h
  group tools
    ./tools/: vofa.c vofa.h
  group DSP
    ./DSP/: arm_cortexM4lf_math.lib
    ./DSP/include/: arm_common_tables.h arm_const_structs.h arm_math.h core_sc000.h core_sc300.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
